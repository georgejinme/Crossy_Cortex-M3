# Keil uVision project Experiment.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S9B92 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Experiment
  c flags: wLevel=2
  c define: rvmdk PART_LM3S9B92 TARGET_IS_TEMPEST_RC3
  c include: ..;..\..\..;F:\Keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\rvmdk\Experiment.sct
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: Startup.s main.c SysCtlConfigure.c SysTickConfigure.c UARTConfigure.c GPIODriverConfigure.c bus.c I2CConfigure.c NixieTubeConfigure.c
    F:/Keil/boards/dk-lm3s9d96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c sound.c tlv320aic23b.c
    F:/Keil/third_party/fatfs/src/: ff.c
    F:/Keil/utils/: ustdlib.c
    F:/Keil/third_party/fatfs/port/: mmc-dk-lm3s9b96.c
  group Document
    ./: readme.txt
  group library
    F:/Keil/grlib/rvmdk-cm3/: grlib-cm3.lib
    F:/Keil/driverlib/rvmdk-cm3/: driverlib-cm3.lib
